COMPATIBLE_MACHINE:rock-3b = "rock-3b"

FILESEXTRAPATHS:prepend := "${THISDIR}/files/${MACHINE}:${THISDIR}/files:"

RAUC_KEYRING_FILE:qemuarm64 = "keyring.pem"
RAUC_KEYRING_FILE:rock-3b = "keyring.pem"
